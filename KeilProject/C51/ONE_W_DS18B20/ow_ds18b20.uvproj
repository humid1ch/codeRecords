# Keil uVision project ow_ds18b20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ow_ds18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Apps;.\Utils
  group Apps
    ./Apps/: smg.c ds18b20.c one_write.c
  group Utils
    ./Utils/: util.c
  group Users
    ./Users/: main.c
