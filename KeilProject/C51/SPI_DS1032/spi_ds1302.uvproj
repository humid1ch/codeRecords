# Keil uVision project spi_ds1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: spi_ds1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Utils;.\Apps
  group Apps
    ./Apps/: smg.c ds1302.c
  group Utils
    ./Utils/: util.c
  group Users
    ./Users/: main.c
