# Keil uVision project pwm_led_breath.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: pwm_led_breath +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Utils;.\Apps
  group Apps
    ./Apps/: pwm.c
  group Users
    ./Users/: main.c
  group Utils
    ./Utils/: util.c
