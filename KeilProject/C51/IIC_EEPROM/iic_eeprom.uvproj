# Keil uVision project iic_eeprom.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: iic_eeprom +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Apps;.\Utils
  group Apps
    ./Apps/: at24c02.c iic.c skey.c smg.c uart.c
  group Utils
    ./Utils/: util.c
  group Users
    ./Users/: main.c
