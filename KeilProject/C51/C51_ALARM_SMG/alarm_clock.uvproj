# Keil uVision project alarm_clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: alarm_clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Utils;.\Apps
  group Apps
    ./Apps/: beep.c ds1302.c one_write.c skey.c smg.c ds18b20.c
  group Users
    ./Users/: main.c
  group Utils
    ./Utils/: util.c
