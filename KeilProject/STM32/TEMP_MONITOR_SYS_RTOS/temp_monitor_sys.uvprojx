# Keil uVision project temp_monitor_sys.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: temp_monitor_sys +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c misc: --no-multibyte-chars
  c include: .\Apps;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Utils;.\Libraries\CMSIS;.\Users;.\FreeRTOS\Include;.\FreeRTOS\Portable\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Apps
    ./Apps/: beep.c ds18b20.c esp8266.c one_write.c skey.c smg.c usart.c timer.c
  group Users
    ./Users/: main.c stm32f10x_it.c
  group Utils
    ./Utils/: utils.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c
    ./Users/: system_stm32f10x.c
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_tim.c
  group FreeRTOS/Portable
    ./FreeRTOS/Portable/ARM_CM3/: port.c
    ./FreeRTOS/Portable/: heap_4.c
  group FreeRTOS/Source
    ./FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
